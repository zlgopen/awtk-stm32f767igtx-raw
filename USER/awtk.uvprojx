# Keil uVision project awtk.uvprojx, settings and files
target awtk (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: awtk +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1,HAS_AWTK_CONFIG
  c misc: --gnu
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\SDRAM;..\HARDWARE\LCD;..\HARDWARE\IIC;..\HARDWARE\TIMER;..\HARDWARE\24CXX;..\HARDWARE\TOUCH;..\HARDWARE\MPU;..\USMART;..\MALLOC;..\awtk\src\ext_widgets;..\awtk;..\awtk\src;..\awtk\3rd;..\awtk\3rd\nanovg\src;..\awtk\3rd\agge\include;..\awtk\3rd\agge\src;..\awtk\3rd\libunibreak\src;..\awtk-port
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_it.c system_stm32f7xx.c
  group CORE
    ../CORE/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: ltdc.c tftlcd.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/TOUCH/: ctiic.c touch.c ft5206.c gt9147.c ott2001a.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/MPU/: mpu.c
  group MALLOC
    ../MALLOC/: malloc.c
  group README
    ../: readme.txt
  group AWTK
    ../awtk/src/base/: app_bar.c array.c assets_manager.c bitmap.c buffer.c button.c button_group.c canvas.c check_button.c color.c color_parser.c color_tile.c column.c combo_box.c combo_box_item.c custom_props.c dialog.c dialog_client.c dialog_title.c dragger.c easing.c edit.c emitter.c enums.c event_queue.c events.c font.c font_manager.c fs.c glyph_cache.c grid.c group_box.c idle.c image.c image_loader.c image_manager.c input_engine.c input_method.c label.c layout.c lcd.c line_break.c locale_info.c main_loop.c matrix.c mem.c pages.c path.c popup.c progress_bar.c rect.c rom_fs.c row.c slider.c spin_box.c str.c suggest_words.c system_info.c tab_button.c tab_button_group.c tab_control.c theme.c time.c timer.c tokenizer.c ui_builder.c utf8.c utils.c value.c velocity.c vgcanvas.c view.c widget.c widget_animator.c widget_factory.c widget_vtable.c window.c window_animator.c window_manager.c wstr.c calibration_win.c
    ../awtk/src/blend/: image_g2d.c stm32_g2d.c soft_g2d.c blend_image_bgr565_bgr565.c blend_image_bgr565_bgra8888.c blend_image_bgr565_rgba8888.c blend_image_bgr888_bgr565.c blend_image_bgr888_bgra8888.c blend_image_bgr888_rgba8888.c blend_image_bgra8888_bgr565.c blend_image_bgra8888_bgra8888.c blend_image_bgra8888_rgba8888.c blend_image_rgb565_bgr565.c blend_image_rgb565_bgra8888.c blend_image_rgb565_rgba8888.c blend_image_rgba8888_bgr565.c blend_image_rgba8888_bgra8888.c blend_image_rgba8888_rgba8888.c fill_image_bgr565.c fill_image_bgr888.c fill_image_bgra8888.c fill_image_rgb565.c fill_image_rgba8888.c rotate_image_bgr565.c rotate_image_bgr888.c rotate_image_bgra8888.c rotate_image_rgb565.c rotate_image_rgba8888.c
    ../awtk/src/input_methods/: input_method_creator.c
    ../awtk/src/font/: font_bitmap.c font_stb.c
    ../awtk/src/image_loader/: image_loader_stb.c
    ../awtk/src/lcd/: lcd_mem_bgra8888.c lcd_mem_rgb565.c lcd_mem_rgba8888.c lcd_mem_bgr565.c lcd_mem_bgr888.c
    ../awtk/src/main_loop/: main_loop_simple.c
    ../awtk/src/misc/: new.cpp
    ../awtk/src/ui_loader/: ui_binary_writer.c ui_builder_default.c ui_loader.c ui_loader_default.c ui_loader_xml.c ui_serializer.c ui_xml_writer.c window_open.c
    ../awtk/src/vgcanvas/: vgcanvas_nanovg.c
    ../awtk/src/widget_animators/: widget_animator_move.c widget_animator_opacity.c widget_animator_rotation.c widget_animator_scale.c widget_animator_scroll.c widget_animator_value.c
    ../awtk/src/window_animators/: window_animator_fb.c
    ../awtk/src/xml/: xml_builder.c xml_parser.c
    ../awtk/src/: awtk.c
    ../awtk/src/input_engines/: input_engine_null.c
  group AWTK-PORT
    ../awtk-port/: main_loop_stm32_raw.c platform.c
    ../awtk/src/platforms/raw/: fs_os.c mutex_null.c
  group AWTK-DEMOS
    ../awtk/demos/: assets.c demo_main.c demo_ui_app.c
  group LIBUNIBREAK
    ../awtk/3rd/libunibreak/src/: graphemebreak.c graphemebreakdata.c linebreak.c linebreakdata.c linebreakdef.c unibreakbase.c unibreakdef.c wordbreak.c wordbreakdata.c
  group NANOVG
    ../awtk/3rd/nanovg/src/: nanovg.c
  group AGGE
    ../awtk/3rd/agge/src/agge/: math.cpp nanovg_agge.cpp nanovg_vertex.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp
  group EXT_WIDGETS
    ../awtk/src/ext_widgets/color_picker/: color_component.c color_picker.c rgb_and_hsv.c
    ../awtk/src/ext_widgets/guage/: guage.c
    ../awtk/src/ext_widgets/image_animation/: image_animation.c
    ../awtk/src/ext_widgets/keyboard/: candidates.c keyboard.c
    ../awtk/src/ext_widgets/rich_text/: rich_text.c rich_text_node.c rich_text_parser.c rich_text_render_node.c
    ../awtk/src/ext_widgets/scroll_view/: list_item.c list_view.c list_view_h.c scroll_bar.c scroll_view.c
    ../awtk/src/ext_widgets/slide_view/: slide_view.c
    ../awtk/src/ext_widgets/switch/: switch.c
    ../awtk/src/ext_widgets/text_selector/: text_selector.c
    ../awtk/src/ext_widgets/time_clock/: time_clock.c
    ../awtk/src/ext_widgets/: ext_widgets.c
target STemWin RGBLCD (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: as above
  output: Template +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STM32F767xx,USE_HAL_DRIVER,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\SDRAM;..\HARDWARE\LCD;..\HARDWARE\TIMER;..\HARDWARE\TOUCH;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\MPU;..\USMART;..\MALLOC;..\DSP_LIB\Include;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\UCOS-BSP;..\UCOSIII\UCOS-CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\EMWIN\STemWin\inc;..\EMWIN\STemWin\Config;..\EMWIN_DEMO\2D_DISPLAY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
